<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\..\assignments\big ass\assignment.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\IAR\Smart Home\Smart Home.ewp</path>
    </project>
    <batchBuild />
</workspace>
